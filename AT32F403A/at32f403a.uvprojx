# Keil uVision project at32f403a.uvprojx, settings and files
target AT32F403A (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F403ACCT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f403a +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ACCT7
  c include: .\RTE\_AT32F403A;.\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc;.\NET\CJSON;.\OLED;.\Serial;.\system;.\RFID;.\NET\Broker\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group core
    ./core/: core_cm4.c at32f403a_407_it.c system_at32f403a_407.c
    ./core/startup/arm/: startup_at32f403a_407.s
  group fwlib
    ./fwlib/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group hardware
    ./hardware/src/: delay.c usart.c
  group user
    ./user/: main.c
  group NET
    ./NET/Broker/src/: Broker.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
  group CJSON
    ./NET/CJSON/: cJSON.c
  group OLED
    ./OLED/: OLED.c
  group system
    ./system/: Timer.c Flash.c
  group RFID
    ./RFID/: RFID.c
software components: CMSIS:CORE 5.6.0
